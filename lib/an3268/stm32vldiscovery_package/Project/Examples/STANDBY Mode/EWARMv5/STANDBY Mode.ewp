# IAR project STANDBY Mode.ewp, settings and files
configuration STANDBY Mode (ARM, debug)
  General.RTConfigPath: $TOOLKIT_DIR$\INC\DLib_Config_Full.h
  General.OGChipSelectEditMenu: STM32F100xB ST STM32F100xB
  ICCARM.CCDefines: USE_STDPERIPH_DRIVER; STM32F10X_MD_VL
  ICCARM.CCIncludePath2: ..\; ..\..\..\..\Libraries\CMSIS\CM3\CoreSupport; ..\..\..\..\Libraries\CMSIS\CM3\DeviceSupport\ST\STM32F10x; ..\..\..\..\Libraries\STM32F10x_StdPeriph_Driver\inc; ..\..\..\..\Utilities
  ICCARM.CCStdIncludePath: $TOOLKIT_DIR$\INC\
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 1
  OBJCOPY.OOCOutputFile: Project.srec
  ILINK.IlinkOutputFile: Project.out
  ILINK.IlinkIcfFile: stm32f10x_flash.icf
  ILINK.IlinkProgramEntryLabel: Reset_Handler
  group CMSIS
    ../../../../Libraries/CMSIS/CM3/CoreSupport/: core_cm3.c
    ../../../../Libraries/CMSIS/CM3/DeviceSupport/ST/STM32F10x/: system_stm32f10x.c
  group Doc
    ../: readme.txt
  group EWARMv5
    ../../../../Libraries/CMSIS/CM3/DeviceSupport/ST/STM32F10x/startup/iar/: startup_stm32f10x_md_vl.s
  group StdPeriph_Driver
    ../../../../Libraries/STM32F10x_StdPeriph_Driver/src/: misc.c stm32f10x_bkp.c stm32f10x_exti.c stm32f10x_gpio.c stm32f10x_pwr.c stm32f10x_rcc.c stm32f10x_rtc.c
  group stm32vldiscovery
    ../../../../Utilities/: STM32vldiscovery.c
  group User
    ../: main.c stm32f10x_it.c
